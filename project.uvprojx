# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,
  c include: .\Start;.\Library\inc;.\User;.\System;.\HardWare\LED;.\HardWare\Key;.\System\delay;.\System\sys;.\HardWare\Systick;.\HardWare\beep;.\HardWare\exti;.\HardWare\usart;.\HardWare\Timer;.\HardWare\pwm;.\HardWare\usart;.\HardWare\Dht11;.\HardWare\iic;.\HardWare\at24c02;.\HardWare\oled;.\HardWare\adc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: stm32f4xx_it.c main.c system_stm32f4xx.c
    ./Start/: startup_stm32f40_41xxx.s
  group Library
    ./Library/src/: misc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c
  group HardWare
    ./HardWare/LED/: led.c
    ./HardWare/Key/: key.c
    ./HardWare/Systick/: Systick.c
    ./HardWare/beep/: beep.c
    ./HardWare/exti/: exti.c
    ./HardWare/Timer/: timer.c
    ./HardWare/pwm/: pwm.c
    ./HardWare/usart/: usart.c
    ./HardWare/Dht11/: dht11.c
    ./HardWare/iic/: iic.c
    ./HardWare/at24c02/: at24c02.c
    ./HardWare/oled/: oled.c
    ./HardWare/adc/: adc.c
  group System
    ./System/sys/: sys.c
    ./System/delay/: delay.c
